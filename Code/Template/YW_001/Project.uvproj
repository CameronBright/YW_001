# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Hardware;.\Startup;.\Readme
  group Startup
    ./Startup/: ISR.ASM
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/: key.c timer.c gpio.c config.c seg.c eeprom.c
  group Readme
    ./Readme/: Readme.txt
