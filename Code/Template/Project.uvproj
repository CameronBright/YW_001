# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Hardware;.\Startup;.\Readme
  group Startup
    ./Startup/: ISR.ASM
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/: key.c timer.c gpio.c config.c seg.c eeprom.c uart.c
  group Readme
    ./Readme/: Readme.txt
